File: pico.kicad_sch (KiCad schematic)
At the start: 51 parts, among them J1 MIDI_OUT, J15 MIDI IN/OUT, J16 MIDI OUT J, J17 MIDI IN J, J2 MIDI_IN, J3 EXP, J4 RGB_LED_EXT, J5 Pico USB TP, SW1 D, SW2 E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

Commit message: Add Power Supply
Parts:
- added H10: Midi Bites, Pedalboard Library:MIDI bites, symbol Mechanical:MountingHole
Other:
- note added: "MIDI Bites allow to remove some of the board material that is used to hold the DIN5 or 3.5mm Jack connectors and instead mount the connectors to the case and wire them up with J15"
- moved on the sheet: SW1, SW2, SW3, SW4, SW5, SW6

Commit message: Fix some kibot warnings
Parts:
- L1, L2, L3, L4, L5: value 1K@100MHz -> 103 / 100MHz
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "1K@100MHz" (at 52.07 88.9 90)
+    (property "Value" "103 / 100MHz" (at 52.07 88.9 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "1K@100MHz" (at 166.37 29.21 90)
+    (property "Value" "103 / 100MHz" (at 166.37 29.21 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Value" "1K@100MHz" (at 31.75 77.47 90)
+    (property "Value" "103 / 100MHz" (at 31.75 77.47 90)
       (effects (font (size 1.27 1.27)))
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "1K@100MHz" (at 44.45 37.465 0)
+    (property "Value" "103 / 100MHz" (at 44.45 37.465 0)
       (effects (font (size 1.27 1.27)) (justify right))
     )
@@
       (effects (font (size 1.27 1.27)) (justify right))
     )
-    (property "Value" "1K@100MHz" (at 17.78 44.45 90)
+    (property "Value" "103 / 100MHz" (at 17.78 44.45 90)
       (effects (font (size 1.27 1.27)) (justify right))
     )
