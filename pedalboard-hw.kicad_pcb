File: pedalboard-hw.kicad_pcb (KiCad board)
At the start: 2 copper layers, 170 x 105 mm, 58 parts, among them J1 MIDI_OUT, J10 Audio IN Left, J11 Audio OUT Right, J12 Audio OUT Left, J13 Audio OUT, J14 Audio IN, J15 MIDI IN/OUT, J16 MIDI OUT J, J17 MIDI IN J, J2 MIDI_IN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

Commit message: Connect USB
Parts:
- moved C5 7.34 mm to (147.1, 48.0), turned to 90 degrees
- moved C4 3.40 mm to (113.0, 52.2)
Connections:
- net /Audio/USB_DM renamed /Audio/USB_DN
Routing:
- net /Audio/V_BUS: track 0.00 -> 110.6 mm, vias 0 -> 1
- net /Audio/USB_DN: track 0.00 -> 103.5 mm
- net /Audio/USB_DP: track 0.00 -> 100.8 mm
- net /MIDI/SW_C: track 109.2 -> 138.4 mm
- net GND: track 8.31 -> 36.6 mm
- net /MIDI/SW_F: track 75.3 -> 93.7 mm
- net Net-(U1-GPIO28_ADC2): track 75.1 -> 80.9 mm
- net /MIDI/SW_GAIN: track 71.7 -> 76.8 mm
- net /MIDI/ROT_GAIN_B: track 48.5 -> 52.5 mm
- net Net-(U1-ADC_VREF): track 68.2 -> 65.9 mm
- net /MIDI/ROT_GAIN_A: track 62.8 -> 63.4 mm

Commit message: Small routing fixes
Routing:
- net /MIDI/SW_B: track 68.9 -> 81.4 mm
- net Net-(U1-GPIO28_ADC2): track 80.9 -> 76.3 mm
Changed lines of the file:
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@@
   (segment (start 76.68 82.725) (end 73.345 86.06) (width 0.25) (layer "B.Cu") (net 15))
   (segment (start 73.345 86.06) (end 73.345 93.14) (width 0.25) (layer "B.Cu") (net 15))
+  (segment (start 181.965 33.8) (end 180.14 31.975) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 131.551396 36.685) (end 113.705 36.685) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 138.023604 38.14) (end 133.006396 38.14) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 180.14 31.975) (end 174.85906 31.975) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 113.705 36.685) (end 111.89 38.5) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 133.006396 38.14) (end 131.551396 36.685) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 173.48406 33.35) (end 142.813604 33.35) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 111.89 38.5) (end 111.89 40.11) (width 0.25) (layer "B.Cu") (net 16))
   (segment (start 142.813604 33.35) (end 138.023604 38.14) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 131.551396 36.685) (end 113.705 36.685) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 177.44 33.04406) (end 176.37094 31.975) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 138.023604 38.14) (end 133.006396 38.14) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 173.48406 33.35) (end 142.813604 33.35) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 176.37094 31.975) (end 174.85906 31.975) (width 0.25) (layer "B.Cu") (net 16))
   (segment (start 174.85906 31.975) (end 173.48406 33.35) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 177.44 34.55594) (end 177.44 33.04406) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 176.37094 35.625) (end 177.44 34.55594) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 113.705 36.685) (end 111.89 38.5) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 111.89 38.5) (end 111.89 40.11) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 133.006396 38.14) (end 131.551396 36.685) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 181.965 33.8) (end 180.14 35.625) (width 0.25) (layer "B.Cu") (net 16))
-  (segment (start 180.14 35.625) (end 176.37094 35.625) (width 0.25) (layer "B.Cu") (net 16))
   (segment (start 110.68 41.44) (end 130.655 41.44) (width 0.25) (layer "B.Cu") (net 17))
   (segment (start 130.655 41.44) (end 133.055 39.04) (width 0.25) (layer "B.Cu") (net 17))
@@
   (segment (start 23.75 114.75) (end 24.7 113.8) (width 0.25) (layer "B.Cu") (net 95))
   (segment (start 101.37 62.4) (end 104.27 59.5) (width 0.25) (layer "B.Cu") (net 95))
-  (segment (start 111.25 116.5) (end 111.85 115.9) (width 0.25) (layer "B.Cu") (net 96))
-  (segment (start 111.85 115.9) (end 118.9 115.9) (width 0.25) (layer "B.Cu") (net 96))
   (segment (start 119.06 115.74) (end 119.06 67.06) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 98.75 116.5) (end 111.25 116.5) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 111.25 116.5) (end 118.3 116.5) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 118.3 116.5) (end 119.06 115.74) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 119.06 67.06) (end 111.89 59.89) (width 0.25) (layer "B.Cu") (net 96))
   (segment (start 111.89 59.89) (end 111.89 57.89) (width 0.25) (layer "B.Cu") (net 96))
-  (segment (start 118.9 115.9) (end 119.06 115.74) (width 0.25) (layer "B.Cu") (net 96))
-  (segment (start 119.06 67.06) (end 111.89 59.89) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 134.655 39.94) (end 133.427792 39.94) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 141.473198 52.121802) (end 137.141396 47.79) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 137.141396 42.426396) (end 134.655 39.94) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 137.141396 47.79) (end 137.141396 42.426396) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 133.427792 39.94) (end 131.027792 42.34) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 159.755 116.44) (end 159.755 57.64) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 122.505 42.34) (end 122.505 50.626396) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 131.027792 42.34) (end 122.505 42.34) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 159.815 116.5) (end 159.755 116.44) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 119.51 53.621396) (end 119.51 57.89) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 134.655 39.94) (end 133.427792 39.94) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 133.427792 39.94) (end 131.027792 42.34) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 154.236802 52.121802) (end 141.473198 52.121802) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 122.505 50.626396) (end 119.51 53.621396) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 159.755 116.54) (end 159.755 57.64) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 137.141396 47.79) (end 137.141396 42.426396) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 131.027792 42.34) (end 122.505 42.34) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 159.755 57.64) (end 154.236802 52.121802) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 173.75 116.5) (end 159.795 116.5) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 122.505 42.34) (end 122.505 50.626396) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 159.795 116.5) (end 159.755 116.54) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 137.141396 42.426396) (end 134.655 39.94) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 173.75 116.5) (end 159.815 116.5) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 73.61 40.11) (end 65 31.5) (width 0.25) (layer "F.Cu") (net 98))
   (segment (start 65 31.5) (end 60.25 31.5) (width 0.25) (layer "F.Cu") (net 98))
@@
     (polygon
       (pts
-        (xy 61.468 124.968)
+        (xy 69.255 124.968)
         (xy 47.752 124.968)
         (xy 36.576 113.792)
@@
         (xy 181.925 94.869)
         (xy 181.925 85.471)
-        (xy 180.147 83.693)
-        (xy 168.717 83.693)
+        (xy 178.247 81.793)
+        (xy 168.717 81.793)
         (xy 168.717 110.998)
         (xy 167.701 112.014)

Commit message: Connect Midi Plugs
Parts:
- moved R5 1.84 mm to (70.6, 56.6)
- moved J15 0.50 mm to (69.1, 72.2)
Routing:
- net Net-(J15-Pin_6): track 23.3 -> 117.8 mm
- net Net-(J15-Pin_4): track 56.1 -> 145.5 mm
- net Net-(J15-Pin_3): track 19.4 -> 97.9 mm
- net Net-(J15-Pin_2): track 12.1 -> 82.1 mm
- net Net-(J15-Pin_1): track 38.2 -> 107.9 mm
- net /MIDI/RGB_DATA: track 20.2 -> 24.3 mm
- net /MIDI/SW_D: track 73.3 -> 74.2 mm
- net Net-(D1-DIN): track 10.1 -> 10.8 mm
- net /MIDI/SW_A: track 154.6 -> 155.3 mm
- net Net-(D1-DOUT): track 21.3 -> 22.0 mm
