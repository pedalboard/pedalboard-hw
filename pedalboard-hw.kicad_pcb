# Repository pedalboard/pedalboard-hw

File README.md:

# Open Pedalboard Mainboard

Mainboard for processing audio and/or MIDI data on a pedalboard.

**[Documentation →](https://pedalboard.github.io/pedalboard-hw/latest/)**

## Design Goals

- Modular: MIDI-only or combined MIDI + audio
- Raspberry Pi CM4/CM5 for audio processing (< 2ms latency)
- RP-2040 MIDI controller with independent firmware
- Maker friendly: common components, existing modules
- Flat design: 30mm case height target

## Links

- [Interactive schematic & PCB viewer](https://pedalboard.github.io/pedalboard-hw/latest/board/)
- [Interactive BOM](https://pedalboard.github.io/pedalboard-hw/latest/board/)
- [Downloads & releases](https://pedalboard.github.io/pedalboard-hw/latest/release/)
- [Digi-Key shared list](https://www.digikey.ch/de/mylists/list/DJ3I9KG222)
- [PCBWay manufacturing](https://www.pcbway.com/project/shareproject/Open_Source_Pedalboard_Platform_8e065d23.html)
- [Mechanical parts (3D printable)](https://github.com/pedalboard/pedalboard-case)
- [Release procedure](doc/release-procedure.md)

## License

## KiCad design pedalboard-hw.kicad_pcb

Parts:
H6, H7, H8, H9: MountingHole; MountingHole_2.7mm_M2.5_DIN965

Parts:
H1, H2, H3, H4, H5: MountingHole; MountingHole_2.7mm_M2.5_DIN965
J6: USB_A; USB A BCB Male Plug
J7: Raspberry_pi; Raspberry PI Compute Module CM4 Nano A
J8: HiFi Berry; HiFi Berry DAC ADC+
J9: Audio IN Right; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal
J10: Audio IN Left; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal
J11: Audio OUT Right; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal
J12: Audio OUT Left; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal
J13: Audio OUT; PinSocket_2x03_P2.54mm_Vertical
J14: Audio IN; PinSocket_2x03_P2.54mm_Vertical

Connections:
/Audio/GND_in_L: J10.S, J14.4
/Audio/GND_in_R: J9.S, J14.3
/Audio/GND_out: J11.S, J12.S, J13.4
/Audio/USB_DN: J6.2 (D-); also elsewhere on the board
/Audio/USB_DP: J6.3 (D+); also elsewhere on the board
/Audio/V_BUS: J6.1 (VBUS); also elsewhere on the board
/Audio/audio_in_L+: J10.T, J14.5
/Audio/in_L-: J10.R, J14.6
/Audio/in_R+: J9.T, J14.2
/Audio/in_R-: J9.R, J14.1
GND: J6.4 (GND), J6.5 (Shield), J7.6 (GND), J7.9 (GND), J7.14 (GND), J7.20 (GND), J7.25 (GND), J7.30 (GND), J7.34 (GND), J7.39 (GND), J8.6 (GND), J8.9 (GND), J8.14 (GND), J8.20 (GND), J8.25 (GND), J8.30 (GND), J8.34 (GND), J8.39 (GND); also elsewhere on the board
unnamed: J7.1 (3V3), J8.1 (3V3)
unnamed: J7.17 (3V3), J8.17 (3V3)
unnamed: J7.2 (5V), J8.2 (5V)
unnamed: J7.4 (5V), J8.4 (5V)
unnamed: J7.7 (GCLK0/GPIO4), J8.7 (GCLK0/GPIO4)
unnamed: J7.29 (GCLK1/GPIO5), J8.29 (GCLK1/GPIO5)
unnamed: J7.31 (GCLK2/GPIO6), J8.31 (GCLK2/GPIO6)
unnamed: J7.8 (GPIO14/TXD), J8.8 (GPIO14/TXD)
unnamed: J7.10 (GPIO15/RXD), J8.10 (GPIO15/RXD)
unnamed: J7.36 (GPIO16), J8.36 (GPIO16)
unnamed: J7.11 (GPIO17), J8.11 (GPIO17)
unnamed: J7.12 (GPIO18/PWM0), J8.12 (GPIO18/PWM0)
unnamed: J7.35 (GPIO19/MISO1), J8.35 (GPIO19/MISO1)
unnamed: J7.38 (GPIO20/MOSI1), J8.38 (GPIO20/MOSI1)
unnamed: J7.40 (GPIO21/SCLK1), J8.40 (GPIO21/SCLK1)
unnamed: J7.15 (GPIO22), J8.15 (GPIO22)
unnamed: J7.16 (GPIO23), J8.16 (GPIO23)
unnamed: J7.18 (GPIO24), J8.18 (GPIO24)
unnamed: J7.22 (GPIO25), J8.22 (GPIO25)
unnamed: J7.37 (GPIO26), J8.37 (GPIO26)
unnamed: J7.13 (GPIO27), J8.13 (GPIO27)
unnamed: J7.28 (ID_SC/GPIO1), J8.28 (ID_SC/GPIO1)
unnamed: J7.27 (ID_SD/GPIO0), J8.27 (ID_SD/GPIO0)
unnamed: J7.21 (MISO0/GPIO9), J8.21 (MISO0/GPIO9)
unnamed: J7.19 (MOSI0/GPIO10), J8.19 (MOSI0/GPIO10)
unnamed: J7.32 (PWM0/GPIO12), J8.32 (PWM0/GPIO12)
unnamed: J7.33 (PWM1/GPIO13), J8.33 (PWM1/GPIO13)
unnamed: J7.23 (SCLK0/GPIO11), J8.23 (SCLK0/GPIO11)
unnamed: J7.5 (SCL/GPIO3), J8.5 (SCL/GPIO3)
unnamed: J7.3 (SDA/GPIO2), J8.3 (SDA/GPIO2)
unnamed: J7.24 (~CE0/GPIO8), J8.24 (~CE0/GPIO8)
unnamed: J7.26 (~CE1/GPIO7), J8.26 (~CE1/GPIO7)
unnamed: J11.T, J13.2
unnamed: J12.T, J13.6

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12: 100nF; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10: NEOPIX; LED_D5.0mm-NeoPixel
D11: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: MIDI_OUT; CP-2350
J2: MIDI_IN; CP-2350
J3: EXP; Jack_6.35mm_Neutrik_NMJ6HCD2_Horizontal
J4: RGB_LED_EXT; PinHeader_1x03_P2.54mm_Horizontal
J5: Pico USB TP; Spring_Loaded_Pins_2mm
J15: MIDI IN/OUT; PinHeader_2x03_P2.54mm_Horizontal
J16: MIDI OUT J; Jack_3.5mm_CUI_SJ1-3525N_Horizontal
J17: MIDI IN J; Jack_3.5mm_CUI_SJ1-3525N_Horizontal
L1, L2, L3, L4, L5: 1K@100MHz; L_Axial_L6.6mm_D2.7mm_P10.16mm_Horizontal_Vishay_IM-2
R1: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R5: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 33; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 10; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: D; SW_PUSH-12mm_Wuerth-430476085716
SW2: E; SW_PUSH-12mm_Wuerth-430476085716
SW3: F; SW_PUSH-12mm_Wuerth-430476085716
SW4: A; SW_PUSH-12mm_Wuerth-430476085716
SW5: B; SW_PUSH-12mm_Wuerth-430476085716
SW6: C; SW_PUSH-12mm_Wuerth-430476085716
SW7: VOL Rotary; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_CircularMoun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
SW8: GAIN Rotary; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm_CircularMoun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
U1: Pico; RPi_Pico_SMD_TH
U2: H11L1; DIP-6_W7.62mm_LongPads

Connections:
+3.3V: C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, D1.2 (VDD), D2.2 (VDD), D3.2 (VDD), D4.2 (VDD), D5.2 (VDD), D6.2 (VDD), D7.2 (VDD), D8.2 (VDD), D9.2 (VDD), D10.2 (VDD), J4.3, R2.1, R3.1, U1.36 (3V3), U2.6
/Audio/USB_DN: J5.1; also elsewhere on the board
/Audio/USB_DP: J5.2; also elsewhere on the board
/Audio/V_BUS: L5.2; also elsewhere on the board
/MIDI/RGB_DATA: R5.1, U1.15 (GPIO11)
/MIDI/ROT_GAIN_A: SW8.A, U1.25 (GPIO19)
/MIDI/ROT_GAIN_B: SW8.B, U1.26 (GPIO20)
/MIDI/ROT_VOL_A: SW7.A, U1.21 (GPIO16)
/MIDI/ROT_VOL_B: SW7.B, U1.22 (GPIO17)
/MIDI/SW_A: SW4.1, U1.10 (GPIO7)
/MIDI/SW_B: SW5.1, U1.7 (GPIO5)
/MIDI/SW_C: SW6.1, U1.4 (GPIO2)
/MIDI/SW_D: SW1.1, U1.9 (GPIO6)
/MIDI/SW_E: SW2.1, U1.6 (GPIO4)
/MIDI/SW_F: SW3.1, U1.5 (GPIO3)
/MIDI/SW_GAIN: SW8.S1, U1.27 (GPIO21)
/MIDI/SW_VOL: SW7.S1, U1.24 (GPIO18)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D1.3 (GND), D2.3 (GND), D3.3 (GND), D4.3 (GND), D5.3 (GND), D6.3 (GND), D7.3 (GND), D8.3 (GND), D9.3 (GND), D10.3 (GND), J1.2, J4.1, J15.5, J16.S, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.C, SW7.S2, SW8.C, SW8.S2, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U2.5; also elsewhere on the board
unnamed: D1.1 (DIN), R5.2
unnamed: D1.4 (DOUT), D2.1 (DIN)
unnamed: D2.4 (DOUT), D3.1 (DIN)
unnamed: D3.4 (DOUT), D4.1 (DIN)
unnamed: D4.4 (DOUT), D5.1 (DIN)
unnamed: D5.4 (DOUT), D6.1 (DIN)
unnamed: D6.4 (DOUT), D7.1 (DIN)
unnamed: D7.4 (DOUT), D8.1 (DIN)
unnamed: D8.4 (DOUT), D9.1 (DIN)
unnamed: D9.4 (DOUT), D10.1 (DIN)
unnamed: D10.4 (DOUT), J4.2
unnamed: D11.2 (A), L2.2, U2.2
unnamed: D11.1 (K), R1.2, U2.1
unnamed: J2.5, J15.1, J17.T, J17.TN, L2.1
unnamed: C1.1, J2.2, J15.2, J17.S
unnamed: J2.4, J15.3, J17.R, J17.RN, L1.1
unnamed: J1.5, J15.4, J16.T, J16.TN, L4.1
unnamed: J1.4, J15.6, J16.R, J16.RN, L3.1
unnamed: L1.2, R1.1
unnamed: L3.2, R3.2
unnamed: L4.2, R4.1
unnamed: J3.T, U1.35 (ADC_VREF)
unnamed: J3.RN, J3.S, U1.33 (AGND)
unnamed: R4.2, U1.1 (GPIO0)
unnamed: R2.2, U1.2 (GPIO1), U2.4
unnamed: J3.R, U1.34 (GPIO28_ADC2)
unnamed: C12.1, L5.1, U1.40 (VBUS)

Board: 2 copper layers, 170.0 x 105.0 mm, 69 parts (8 on the bottom side), 86 nets.

## Commit log (part)

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2023-10-12 Fix all DRC erors
2023-10-12 Fix zones
2023-10-12 Use 12x12mm tactile buttons (SMD)
2023-10-12 Fix button footprint (was THT instead of SMD)
2023-10-12 Add footprint for level converter
2023-10-12 Improve 5V Power Zone
2023-10-12 JST connector for MIDI
2023-10-12 Changelog
2023-10-13 Compiatility with 1590DD enclosure
2023-10-13 Cleanup MIDI circuit (extremley high density
2023-10-13 Fix LED locations
2023-10-13 Add fiducials for p&p
2023-10-14 PSU: document improvements
2023-10-14 Cleanup zones
2023-10-14 PSU rethinking...
2023-10-15 Initial Revision of CM4
2023-10-15 Set the GPIO reference to 3.3V
2023-10-16 Add a CM4 module to the 3d view
2023-10-16 Driver for LED
2023-10-16 Optimise vias and tracks
2023-10-16 Cleanup tracks and vias
2023-10-16 Route the USB connection
2023-10-16 Add mounting hole for sound card
2023-10-16 Remove unused footprints
2023-10-16 Exclude curtyard violations
2023-10-16 Set clearance to comply with DRC
2023-10-16 Remove traces of CM4 Namo
2023-10-16 Add some TODOs
2023-10-16 Discrete power supply
2023-10-16 Exclude power supply violoations
2023-10-16 Add a debug header
2023-10-17 Route Differential pair for USB
2023-10-17 Route Differential ignore ERC
2023-10-17 Update led ring
2023-10-18 Remove left-over connection
2023-10-18 Squashed commit of the following:
    commit 3fa4ca4d3c5ea62d251efd6d8a974a8ccaef8e6e
    Author: Christof Laenzlinger <6319634+laenzlinger@users.noreply.github.com>
    Date: Thu Oct 19 01:43:32 2023 +0200
    Cleanup Silkscreen
    commit 95b56afabf9d984d42b570e7dd0e9dc0995e2e0a
    Author: Christof Laenzlinger <6319634+laenzlinger@users.noreply.github.com>
2023-10-19 Exclude ERD
2023-10-19 Small layout improvements
2023-10-19 Disable DRC, disable ERC
2023-10-19 Add 3d model for USB
2023-10-19 Add alternative terminal for power
2023-10-19 Improve CHANGELOG
2023-10-19 Release preparations
2023-10-19 Change doc links
2023-10-19 Fix links to doc
2023-10-19 Improve doc PDF links
2023-10-19 Update CHANGELOG.md
    improvments
2023-10-19 Update CHANGELOG.md
    move FUTURE_IMPROVEMENTS into issues
2023-10-19 Bump Version to 3.0.1-RC1
2023-10-20 Increase siye of plated slot
2023-10-20 Set release date
2023-10-21 lock more components
2023-10-22 Add new Fiducials
2023-10-22 Add a KiCanvas link
2023-10-22 Consistent (small) symbol for all resistors
2023-10-22 Add supplier to HTML BOM
2023-10-22 Improve BOM: Same components have same value
2023-10-22 Cleanup Supplier link for CM4
2023-10-22 Diff to last release
2023-10-22 Improve spacer 3d model and datasheet
2023-10-22 Update README.md
    Fix name of RP-2040
2023-10-22 Add spacer step model
2023-10-22 Fix Supplier Link for 22uF capacitor
2023-10-22 DNP for MIDI connectors
2023-10-23 Align symbol for diodes
2023-10-23 Use project symbol library
2023-10-23 Use CM4 of symbol library
2023-10-23 Update README.md
    remove WIFI (since its not anymore supported)
2023-10-23 Fix datasheet urls
2023-10-29 Update features to V3
2023-11-05 New OpenPnP job
2023-11-06 simplify part names
2023-11-15 pnp reset
2023-11-21 Fix USB Boot mode bug
2023-11-26 Invert CM4 power LED
2023-11-26 Add TODO to changelog
2023-11-29 Use PSU design based on CM4IO V5 board
2023-11-29 Update References
2023-12-01 Add tactile button for USB boot
2023-12-02 Add tactile button for reset (RP2040)
2023-12-02 Increase activity LED resistor value
2023-12-02 Reset works, no need for change
2023-12-02 Reduce the solder paste size for rp2040 anc cm4 connectors in 20%
2023-12-02 Cleanup part list
2023-12-02 Fix buttons
2023-12-02 Fix 3d model of buck converter
2023-12-03 Reduce the solder paste size for rp2040 anc cm4 connectors 10%
2023-12-03 Optimize tracks
2023-12-03 Add one Led ring
2023-12-03 Add 2nd Led ring
2023-12-03 Simplify 3d Model
2023-12-03 Centralize MIDI circuit
2023-12-03 Add Stemma connector to README
2023-12-03 Small Silkscreen improvments
2023-12-04 Refill zones
2023-12-04 Stemma Spec for LED Out
2023-12-04 Use JST PH consistently (since its also used by STEMMA
2023-12-04 Revert "Soldermask color to white"
    This reverts commit 0fb851f5ae9f513fe24f1a630c152fa3989f80b8.
2023-12-04 Revert "try some new colors for 3d view"
    This reverts commit f849c1d0f29300a9a1679607f3b9d7c0fa9f5f5f.
2023-12-04 Align capacitor symbols
2023-12-04 Align resistor symbols
2023-12-04 3C model is smaller now
2023-12-04 Revert "All 3d images in white"
    This reverts commit cf1a680a94822b390be0284eadb46a3dacae5ada.
2023-12-04 Bump version to 3.1.0
2023-12-04 Bump version to 3.1.1-RC
2023-12-05 Bump version to 3.1.1
2023-12-05 Fis readme links
2023-12-23 Add link to soundcard
2023-12-24 All parts enabled
2023-12-26 Defer the error handling for all parts
2023-12-27 Prepare for next release, add OSHW symbol and cleanup BOM
2023-12-27 Use knockout connector text and improve silkscreen
2023-12-27 Use blender 3d views
2024-01-01 Add TODOs
2024-01-06 Add improvements
2024-01-07 Revert the power silkscreen symbol
2024-01-07 Add commit hash to PCB
2024-01-07 Add more preflight checks
2024-01-07 Fix prefilight
2024-01-07 Ignore unresolved GIT_HASH
2024-01-07 Add pull-up resistors for I2C output
2024-01-07 DNP the USB connector
2024-01-07 Replace HiFi Berry by pedalboard-soundcard
2024-01-07 Reorder TODOs
2024-01-07 Add a 3d model for JST connector
2024-01-07 Show screw terminal instead on 3d view (DNP for jack barrel)
2024-10-04 Use latest github actions
2024-10-09 Update to V4
2024-10-09 Fix stencil generator
2024-10-09 Add 3d model for stemma
2024-10-09 One more mounting whole
2024-10-09 Use smaller (recommended XTAL)
2024-10-10 Update LED Resistor
2024-10-10 First version of USB-Hub
2024-10-12 First routing. Still many issues
2024-10-12 Reset the location of the RP header
2024-10-13 Move the 3v power supply to free space for the LED connector
2024-10-13 Move the LED connector
2024-10-13 Switch top layer from +5V to GND
2024-10-13 3D model for micro USB connector
2024-10-13 Cleanup mounting holes and therefore routing
2024-10-13 Align mounting hole positions
2024-10-13 README.md
2024-10-14 Cleanup audio output schematic
2024-10-14 Cleanup audio input schematic
2024-10-14 Cleanup silkscreen and vias
2024-10-14 Add curtyard
2024-10-14 Add describing text for jumpers
2024-10-14 USB grounding option and protection
2024-10-14 EEPROM
2024-10-14 Update CHNGELOG
2024-10-15 Last PCB improvments
2024-10-15 Fix typo and ESC errors
2024-10-15 Add makefile for testing
2024-10-15 Add step model export
2024-10-15 Add bom output to Makefile
2024-10-15 Add pos file output
2024-10-15 Add erc run
2024-10-15 Connect all OCS pins
2024-10-15 Fix Datasheet for XTAL
2024-10-15 Add Datasheets
2024-10-15 Document Makefile
2024-10-15 Use ascii format
2024-10-15 Change resistor value for test led
2024-10-16 Fix symbol warnings
2024-10-16 Fix new errors
2024-10-16 Use stadard KiCAD inductor symbol
2024-10-16 Add missing symbol to library
2024-10-16 Fix duplicate net warning
2024-10-16 Fix last warning
2024-10-16 Fix 3d models
2024-10-16 Bump version
2024-10-16 Bump version to 4.0.1
2024-10-16 Fix version
2024-10-17 Improve Makefile
2024-10-17 Revert README to latest
2024-10-27 Fix Footprints reported by DRC
2024-10-28 Improve kibot config deprication warnings
2024-10-28 Hard code version
2024-10-28 Downgrade KiBot
2024-10-31 Add bom2inventree script
2024-10-31 Use longer encoder
2024-11-15 set board position
2024-11-16 Better datasheet for USB otg connector
2024-12-08 Disable parts from being picked and placed
2024-12-15 Update jig size
2024-12-15 Use short git hash in Makefile
2024-12-16 Replace deprecated parameter
2025-03-01 Update README.md
    mention also CM5
2025-03-02 Upgrade to kicad9
2025-03-14 update release procecure with OSHWA
2025-04-21 Schema: Update to kicad v9
2025-04-21 PCB: Update to kicad v9
2026-04-14 Deploy to gh-pages branch, fix doc versioning
    - Replace cross-repo deploy to pedalboard-hw-site with gh-pages branch
    in the same repo using JamesIves/github-pages-deploy-action
    - Add tag-triggered versioned deploy (vX.Y.Z/ folders)
    - Add root index.html redirect to latest docs
    - Update all URLs in README.md
    - Simplify release procedure (no more manual site-repo tagging)
2026-04-14 ci: install rsync for gh-pages deploy
2026-04-14 Deploying to gh-pages from @ pedalboard/pedalboard-hw@b14573be9e4d223585a8331e8defae62b5e8e032 🚀
2026-04-14 Add version picker landing page
    - Replace simple redirect with landing page featuring version dropdown
    - CI generates versions.json by scanning gh-pages branch for v* folders
    - Landing page and versions.json deployed to gh-pages root
2026-04-14 Fix version picker: add Go button, include old versions
    - Add placeholder option and Go button so selection always works
    - Include old versions from pedalboard-hw-site with absolute URLs
    - Support both string and object entries in versions.json
2026-04-14 Deploying to gh-pages from @ pedalboard/pedalboard-hw@313b87751650d2a540e8475a2fa679501706a960 🚀
2026-04-14 Deploying to gh-pages from @ pedalboard/pedalboard-hw@9ea117b010ebe035f1315b747b716b4a89ace88a 🚀
2026-04-14 ci: add .nojekyll to fix GitHub Pages build
2026-04-14 Link GitHub repo to selected tag
2026-04-14 Deploying to gh-pages from @ pedalboard/pedalboard-hw@0a9a88d452d21fb93adcf28697441eda3cb0d486 🚀
2026-04-15 Fix CI: remove 'local' keyword (not POSIX sh)
2026-04-18 reset versions.json for new theme
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@2bba0d613dfe869c9d7fd8f9dc5a92988596192b 🚀
2026-04-18 add old releases to version picker
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@67c7957b3a5df34d1637cefd0bf62eb8bf1747f7 🚀
2026-04-18 overview: add OSHWA and license badges
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@e14b17e0466541e0b6478bd306616b03e0dee0ca 🚀
2026-04-18 remove redundant badges from overview (now in footer)
2026-04-18 remove outdated wiki link
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@4ab1a91a663de92c5c88eef77692aca468400c7d 🚀
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@3836d78b93d9566fe9b4ab192d5479bfe8b980ad 🚀
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@7cca40376028e236e7a5901d226808d6f52b069f 🚀
2026-04-18 trigger rebuild (diff discovery fix)
2026-04-18 remove duplicate OSHWA link (now in footer)
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@353350d13a540cd37dc76621a53ee8fdae1464a8 🚀
2026-04-18 Deploying to gh-pages from @ pedalboard/pedalboard-hw@f235d37784b7ca468449f4418a9834ef58fe83b8 🚀
2026-04-21 site: add .mise.toml, update theme vendor (hugo-kicad-site v1.0.3)
2026-04-21 ci: remove kibot_install (3D models now cached by workflow)
2026-04-21 Deploying to gh-pages from @ pedalboard/pedalboard-hw@30053682583ca1e58ebc053573f9bd41f36dc1ae 🚀
2026-04-22 gitignore: add .history
2026-04-22 fix USB connector shield pad names for KiCad 10
    - Rename pad 6 to SH in custom USB Micro-B footprint (J9)
    - Update J10 USB-A footprint from library (pad 5 to SH)
    - Resolves DRC shorting/unconnected errors on shield nets
2026-04-22 fix Y2 crystal courtyard and update remaining footprints
    - Fix malformed courtyard in ABM8-272-T3_ABR footprint (self-intersecting/unclosed)
    - Update Y2 footprint in PCB from library
    - Remove stale DRC exclusion for unresolved_variable
    - ERC: 0 violations, DRC: 0 violations
2026-04-22 KiCad 10 CI cleanup: remove HPGL/pcbdraw/render_3d outputs, align Blender config, use workflow defaults
2026-04-22 Deploying to gh-pages from @ pedalboard/pedalboard-hw@99058ce3b2bc7db122aa04b2066b6492c6121c5a 🚀
2026-04-22 Deploying to gh-pages from @ pedalboard/pedalboard-hw@795abf0cfc1b3fdfd56228734d54c9afae338df5 🚀
2026-04-22 Fix TRS jack 3D model path (KICAD8 → KICAD10, .wrl → .step)
2026-04-22 Deploying to gh-pages from @ pedalboard/pedalboard-hw@7c74a995afc82f0e6f8ec621e720139771ace52b 🚀
2026-04-22 Deploying to gh-pages from @ pedalboard/pedalboard-hw@0643ffc8a3c25504013df19ee2130fe43e93dc92 🚀
2026-04-23 Add GitHub icon to header menu link
2026-04-23 Update TRS jack footprints with 3D model (J1, J3)
2026-04-23 Deploying to gh-pages from @ pedalboard/pedalboard-hw@19a4a007c443f2ce66223c409e986791648e9280 🚀
2026-05-06 Deploying to gh-pages from @ pedalboard/pedalboard-hw@4556f77742bb58dab70e087f2faccfbc25d61b13 🚀
2026-05-12 Deploying to gh-pages from @ pedalboard/pedalboard-hw@a6112d2a64ef4cfee851380c76a29725455375e4 🚀

Notices in the files:
README.md:
[OSHWA Certified](https://certification.oshwa.org/ch000023.html) [License: CERN-OHL-P-2.0](LICENSE.txt)
pedalboard-hw.kicad_pcb:
License: CERN Open Hardware Licence Version 2 - Permissive
