File: pedalboard-hw.kicad_pcb (KiCad board)
At the start: 2 copper layers, 170 x 105 mm, 58 parts, among them J1 MIDI_OUT, J10 Audio IN Left, J11 Audio OUT Right, J12 Audio OUT Left, J13 Audio OUT, J14 Audio IN, J15 MIDI IN/OUT, J16 MIDI OUT J, J17 MIDI IN J, J2 MIDI_IN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

Commit message: Add power panes again
Routing:
- net /MIDI/SW_C: track 92.0 -> 109.2 mm
- net /MIDI/SW_B: track 61.0 -> 68.9 mm
- added copper zone on F.Cu, net +3.3V
- added copper zone on B.Cu, net GND
Changed lines of the file:
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@@
   (segment (start 23.75 114.75) (end 24.7 113.8) (width 0.25) (layer "B.Cu") (net 95))
   (segment (start 101.37 62.4) (end 104.27 59.5) (width 0.25) (layer "B.Cu") (net 95))
+  (segment (start 111.25 116.5) (end 111.85 115.9) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 111.85 115.9) (end 118.9 115.9) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 119.06 115.74) (end 119.06 67.06) (width 0.25) (layer "B.Cu") (net 96))
   (segment (start 111.89 59.89) (end 111.89 57.89) (width 0.25) (layer "B.Cu") (net 96))
-  (segment (start 114.5 62.5) (end 111.89 59.89) (width 0.25) (layer "B.Cu") (net 96))
-  (segment (start 111.25 116.5) (end 114.5 113.25) (width 0.25) (layer "B.Cu") (net 96))
-  (segment (start 114.5 113.25) (end 114.5 62.5) (width 0.25) (layer "B.Cu") (net 96))
-  (segment (start 164.2 110.3) (end 148.838299 110.3) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 118.9 115.9) (end 119.06 115.74) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 119.06 67.06) (end 111.89 59.89) (width 0.25) (layer "B.Cu") (net 96))
+  (segment (start 164.2 110.3) (end 119.51 110.3) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 170.4 116.5) (end 164.2 110.3) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 173.75 116.5) (end 170.4 116.5) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 170.4 116.5) (end 164.2 110.3) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 119.51 80.971701) (end 119.51 57.89) (width 0.25) (layer "B.Cu") (net 97))
-  (segment (start 148.838299 110.3) (end 119.51 80.971701) (width 0.25) (layer "B.Cu") (net 97))
+  (segment (start 119.51 110.3) (end 119.51 57.89) (width 0.25) (layer "B.Cu") (net 97))
   (segment (start 73.61 40.11) (end 65 31.5) (width 0.25) (layer "F.Cu") (net 98))
   (segment (start 65 31.5) (end 60.25 31.5) (width 0.25) (layer "F.Cu") (net 98))
@@
   (segment (start 36.383 107.569) (end 21.778 107.569) (width 0.25) (layer "F.Cu") (net 125))
   (segment (start 23.116 91) (end 21.735 91) (width 0.25) (layer "F.Cu") (net 125))
+  (zone (net 2) (net_name "+3.3V") (layer "F.Cu") (hatch edge 0.5)
+    (priority 1)
+    (connect_pads (clearance 0.4))
+    (min_thickness 0.25) (filled_areas_thickness no)
+    (fill yes (thermal_gap 0.5) (thermal_bridge_width 0.5))
+    (polygon
+      (pts
+        (xy 58.005615 19.994385)
+        (xy 58.005615 58.994385)
+        (xy 20.005615 58.994385)
+        (xy 20.005615 124.994385)
+        (xy 190.005615 124.994385)
+        (xy 190.005615 19.994385)
+        (xy 133.005615 19.994385)
+        (xy 133.005615 35.994385)
+        (xy 133 36)
+        (xy 76.905615 36.094385)
+        (xy 76.905615 19.994385)
+      )
+    )
+  )
   (zone (net 125) (net_name "/Audio/GND_out") (layers "F&B.Cu") (hatch edge 0.5)
     (priority 4)
@@
       )
     )
+  )
+  (zone (net 1) (net_name "GND") (layer "B.Cu") (hatch edge 0.5)
+    (connect_pads (clearance 0.4))
+    (min_thickness 0.25) (filled_areas_thickness no)
+    (fill yes (thermal_gap 0.5) (thermal_bridge_width 0.5))
+    (polygon
+      (pts
+        (xy 58 20)
+        (xy 58 59)
+        (xy 20 59)
+        (xy 20 125)
+        (xy 190 125)
+        (xy 190 20.2)
+        (xy 189.8 20)
+        (xy 133 20)
+        (xy 133 36)
+        (xy 132.99775 36.00225)
+        (xy 76.9 36.1)
+        (xy 76.9 20)
+      )
+    )

Commit message: Move LED extension socket
Parts:
- moved J4 129.0 mm to (53.8, 113.3)
- moved C9 9.55 mm to (43.0, 101.7), turned to 0 degrees
Routing:
- net Net-(U1-AGND): track 0.00 -> 100.1 mm
- net Net-(U1-GPIO28_ADC2): track 0.00 -> 75.1 mm
- net Net-(U1-ADC_VREF): track 0.00 -> 68.2 mm
- net Net-(D10-DOUT): track 0.00 -> 9.50 mm
Changed lines of the file:
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@@
   )
   (footprint "Capacitor_THT:C_Disc_D3.0mm_W1.6mm_P2.50mm" (layer "F.Cu")
-    (at 48.3 109.65 90)
+    (at 43 101.7)
     (descr "C, Disc series, Radial, pin pitch=2.50mm, , diameter*width=3.0*1.6mm^2, Capacitor, http://www.vishay.com/docs/45233/krseries.pdf")
     (tags "C Disc series Radial pin pitch 2.50mm  diameter 3.0mm width 1.6mm Capacitor")
@@
     (property "ki_keywords" "cap capacitor")
     (attr through_hole)
-    (fp_text reference "C9" (at 4.6 0.15 90) (layer "F.SilkS")
+    (fp_text reference "C9" (at 4.6 0.15) (layer "F.SilkS")
         (effects (font (size 1 1) (thickness 0.15)))
     )
-    (fp_text value "100nF" (at 1.25 2.05 90) (layer "F.Fab")
+    (fp_text value "100nF" (at 1.25 2.05) (layer "F.Fab")
         (effects (font (size 1 1) (thickness 0.15)))
     )
-    (fp_text user "${REFERENCE}" (at 1.25 0 90) (layer "F.Fab")
+    (fp_text user "${REFERENCE}" (at 1.25 0) (layer "F.Fab")
         (effects (font (size 0.6 0.6) (thickness 0.09)))
     )
@@
     (fp_line (start 2.75 0.8) (end 2.75 -0.8)
       (stroke (width 0.1) (type solid)) (layer "F.Fab"))
-    (pad "1" thru_hole circle (at 0 0 90) (size 1.6 1.6) (drill 0.8) (layers "*.Cu" "*.Mask")
+    (pad "1" thru_hole circle (at 0 0) (size 1.6 1.6) (drill 0.8) (layers "*.Cu" "*.Mask")
       (net 2 "+3.3V") (pintype "passive"))
-    (pad "2" thru_hole circle (at 2.5 0 90) (size 1.6 1.6) (drill 0.8) (layers "*.Cu" "*.Mask")
+    (pad "2" thru_hole circle (at 2.5 0) (size 1.6 1.6) (drill 0.8) (layers "*.Cu" "*.Mask")
       (net 1 "GND") (pintype "passive"))
     (model "${KICAD6_3DMODEL_DIR}/Capacitor_THT.3dshapes/C_Disc_D3.0mm_W1.6mm_P2.50mm.wrl"
@@
     )
   )
-  (footprint "Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Horizontal" locked (layer "B.Cu")
-    (at 167.415 52.145 90)
+  (footprint "Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Horizontal" (layer "B.Cu")
+    (at 53.825 113.275 90)
     (descr "Through hole angled pin header, 1x03, 2.54mm pitch, 6mm pin length, single row")
     (tags "Through hole angled pin header THT 1x03 2.54mm single row")
@@
     (fp_line (start 10.04 0.32) (end 10.04 -0.32)
       (stroke (width 0.1) (type solid)) (layer "B.Fab"))
-    (pad "1" thru_hole rect locked (at 0 0 90) (size 1.7 1.7) (drill 1) (layers "*.Cu" "*.Mask")
+    (pad "1" thru_hole rect (at 0 0 90) (size 1.7 1.7) (drill 1) (layers "*.Cu" "*.Mask")
       (net 1 "GND") (pinfunction "Pin_1") (pintype "passive"))
-    (pad "2" thru_hole oval locked (at 0 -2.54 90) (size 1.7 1.7) (drill 1) (layers "*.Cu" "*.Mask")
+    (pad "2" thru_hole oval (at 0 -2.54 90) (size 1.7 1.7) (drill 1) (layers "*.Cu" "*.Mask")
       (net 13 "Net-(D10-DOUT)") (pinfunction "Pin_2") (pintype "passive"))
-    (pad "3" thru_hole oval locked (at 0 -5.08 90) (size 1.7 1.7) (drill 1) (layers "*.Cu" "*.Mask")
+    (pad "3" thru_hole oval (at 0 -5.08 90) (size 1.7 1.7) (drill 1) (layers "*.Cu" "*.Mask")
       (net 2 "+3.3V") (pinfunction "Pin_3") (pintype "passive"))
     (model "${KICAD6_3DMODEL_DIR}/Connector_PinHeader_2.54mm.3dshapes/PinHeader_1x03_P2.54mm_Horizontal.wrl"
@@
   (segment (start 45.91 79) (end 45.91 79.365) (width 0.25) (layer "F.Cu") (net 12))
   (segment (start 41.775 81.225) (end 41.775 105.675) (width 0.25) (layer "F.Cu") (net 12))
+  (segment (start 45.91 106) (end 45.91 107.9) (width 0.25) (layer "B.Cu") (net 13))
+  (segment (start 45.91 107.9) (end 51.285 113.275) (width 0.25) (layer "B.Cu") (net 13))
+  (segment (start 180.14 35.625) (end 169.425 35.625) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 181.965 33.8) (end 180.14 35.625) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 135.701396 41.735) (end 113.515 41.735) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 168.1 34.3) (end 143.136396 34.3) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 113.515 41.735) (end 111.89 40.11) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 169.425 35.625) (end 168.1 34.3) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 143.136396 34.3) (end 135.701396 41.735) (width 0.25) (layer "B.Cu") (net 16))
+  (segment (start 135.887792 42.185) (end 111.425 42.185) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 186.1075 36.0075) (end 186.04 36.075) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 186.1075 45.8875) (end 181.965 50.03) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 143.322792 34.75) (end 135.887792 42.185) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 188.315 33.8) (end 186.1075 36.0075) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 169.238604 36.075) (end 167.913604 34.75) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 186.1075 36.0075) (end 186.1075 45.8875) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 111.425 42.185) (end 109.35 40.11) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 167.913604 34.75) (end 143.322792 34.75) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 186.04 36.075) (end 169.238604 36.075) (width 0.25) (layer "B.Cu") (net 17))
+  (segment (start 115.795 37.135) (end 114.43 38.5) (width 0.25) (layer "B.Cu") (net 19))
+  (segment (start 175.615 33.8) (end 143 33.8) (width 0.25) (layer "B.Cu") (net 19))
+  (segment (start 135.515 41.285) (end 131.365 37.135) (width 0.25) (layer "B.Cu") (net 19))
+  (segment (start 131.365 37.135) (end 115.795 37.135) (width 0.25) (layer "B.Cu") (net 19))
+  (segment (start 143 33.8) (end 135.515 41.285) (width 0.25) (layer "B.Cu") (net 19))
+  (segment (start 114.43 38.5) (end 114.43 40.11) (width 0.25) (layer "B.Cu") (net 19))
   (segment (start 146.583802 62.331198) (end 146.583802 61.876198) (width 0.25) (layer "F.Cu") (net 23))
   (segment (start 85.5 68.165438) (end 86.675 69.340438) (width 0.25) (layer "F.Cu") (net 23))

Commit message: Midi Circuit
Parts:
- moved J15 90.7 mm to (69.6, 72.2)
- moved C1 48.1 mm to (73.4, 69.7)
- moved L3 27.5 mm to (61.2, 77.5)
- moved D11 12.6 mm to (81.0, 93.1), turned to 180 degrees
- moved R2 11.8 mm to (64.7, 87.6), turned to 90 degrees
- moved R1 11.2 mm to (81.0, 78.8), turned to -90 degrees
- moved R3 10.3 mm to (70.6, 96.1), turned to 180 degrees
- moved L4 9.62 mm to (67.4, 106.9)
- moved L1 8.42 mm to (70.8, 76.2)
- moved U2 7.66 mm to (76.7, 85.3)
- moved L2 4.54 mm to (60.6, 93.1)
- moved R4 2.69 mm to (81.0, 107.0), turned to 90 degrees
Routing:
- net Net-(U1-GPIO0): track 0.00 -> 88.4 mm
- net Net-(U1-GPIO1): track 0.00 -> 74.4 mm
- net Net-(J15-Pin_4): track 0.00 -> 56.1 mm
- net Net-(J15-Pin_1): track 0.00 -> 38.2 mm
- net Net-(J15-Pin_6): track 0.00 -> 23.3 mm
- net Net-(J15-Pin_3): track 0.00 -> 19.4 mm
- net Net-(D11-A): track 0.00 -> 14.4 mm
- net /MIDI/SW_F: track 62.8 -> 75.3 mm
- net /MIDI/SW_A: track 142.1 -> 154.6 mm
- net /MIDI/SW_E: track 7.93 -> 20.4 mm
- net Net-(J15-Pin_2): track 0.00 -> 12.1 mm
- net Net-(D11-K): track 0.00 -> 10.0 mm
- net Net-(L3-Pad2): track 0.00 -> 9.65 mm
- net GND: track 0.00 -> 8.31 mm
- net Net-(L4-Pad2): track 0.00 -> 3.49 mm
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